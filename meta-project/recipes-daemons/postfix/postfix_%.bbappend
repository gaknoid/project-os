FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append:scarthgap = " file://0001-linux7-host-support-for-native-builds.patch"
