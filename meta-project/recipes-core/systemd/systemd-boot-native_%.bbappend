FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"

DEPENDS += "python3-pefile-native"
